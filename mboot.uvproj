# Keil uVision project mboot.uvproj, settings and files
target mboot (ARM-ADS)
  device: AT91SAM9M10 Atmel
  cpu: IRAM(0x300000-0x30FFFF) IROM(0x400000-0x40FFFF) CLOCK(400000000) CPUTYPE(ARM926EJ-S)
  output: mboot
  AfterMake: fromelf.exe --bin -o  .\output\mboot.bin #L
  c flags: Optim=2
  c define: at91sam9m10 ddram NOFPUT TRACE_LEVEL=4
  c misc: --gnu
  c include: .\atmel;.\
  memory RVCT4: ROM 0x300000 size 0x8000
  scatter file: .\mboot.sct
  link misc: --entry HandlerReset
  group mini
    ./: main.c init_hw.c init_boot.s
  group driver
    ./: dbgu.c cp15.c cp15_init.s
  group mboot
    ./: trace.c system.c shell.c bootx.c
  group atmel
    ./atmel/: aic.c diskio.c dma.c dmad.c ff.c math.c mci_hs.c Media.c MEDSdcard.c pmc.c sdmmc_mci.c
